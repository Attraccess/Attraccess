#include "nfc_emulator/crypto.hpp"

#include <algorithm>

namespace nfc_emulator::crypto {
namespace {
constexpr uint8_t sbox[256] = {
0x63,0x7c,0x77,0x7b,0xf2,0x6b,0x6f,0xc5,0x30,0x01,0x67,0x2b,0xfe,0xd7,0xab,0x76,
0xca,0x82,0xc9,0x7d,0xfa,0x59,0x47,0xf0,0xad,0xd4,0xa2,0xaf,0x9c,0xa4,0x72,0xc0,
0xb7,0xfd,0x93,0x26,0x36,0x3f,0xf7,0xcc,0x34,0xa5,0xe5,0xf1,0x71,0xd8,0x31,0x15,
0x04,0xc7,0x23,0xc3,0x18,0x96,0x05,0x9a,0x07,0x12,0x80,0xe2,0xeb,0x27,0xb2,0x75,
0x09,0x83,0x2c,0x1a,0x1b,0x6e,0x5a,0xa0,0x52,0x3b,0xd6,0xb3,0x29,0xe3,0x2f,0x84,
0x53,0xd1,0x00,0xed,0x20,0xfc,0xb1,0x5b,0x6a,0xcb,0xbe,0x39,0x4a,0x4c,0x58,0xcf,
0xd0,0xef,0xaa,0xfb,0x43,0x4d,0x33,0x85,0x45,0xf9,0x02,0x7f,0x50,0x3c,0x9f,0xa8,
0x51,0xa3,0x40,0x8f,0x92,0x9d,0x38,0xf5,0xbc,0xb6,0xda,0x21,0x10,0xff,0xf3,0xd2,
0xcd,0x0c,0x13,0xec,0x5f,0x97,0x44,0x17,0xc4,0xa7,0x7e,0x3d,0x64,0x5d,0x19,0x73,
0x60,0x81,0x4f,0xdc,0x22,0x2a,0x90,0x88,0x46,0xee,0xb8,0x14,0xde,0x5e,0x0b,0xdb,
0xe0,0x32,0x3a,0x0a,0x49,0x06,0x24,0x5c,0xc2,0xd3,0xac,0x62,0x91,0x95,0xe4,0x79,
0xe7,0xc8,0x37,0x6d,0x8d,0xd5,0x4e,0xa9,0x6c,0x56,0xf4,0xea,0x65,0x7a,0xae,0x08,
0xba,0x78,0x25,0x2e,0x1c,0xa6,0xb4,0xc6,0xe8,0xdd,0x74,0x1f,0x4b,0xbd,0x8b,0x8a,
0x70,0x3e,0xb5,0x66,0x48,0x03,0xf6,0x0e,0x61,0x35,0x57,0xb9,0x86,0xc1,0x1d,0x9e,
0xe1,0xf8,0x98,0x11,0x69,0xd9,0x8e,0x94,0x9b,0x1e,0x87,0xe9,0xce,0x55,0x28,0xdf,
0x8c,0xa1,0x89,0x0d,0xbf,0xe6,0x42,0x68,0x41,0x99,0x2d,0x0f,0xb0,0x54,0xbb,0x16};
constexpr uint8_t rsbox[256] = {
0x52,0x09,0x6a,0xd5,0x30,0x36,0xa5,0x38,0xbf,0x40,0xa3,0x9e,0x81,0xf3,0xd7,0xfb,
0x7c,0xe3,0x39,0x82,0x9b,0x2f,0xff,0x87,0x34,0x8e,0x43,0x44,0xc4,0xde,0xe9,0xcb,
0x54,0x7b,0x94,0x32,0xa6,0xc2,0x23,0x3d,0xee,0x4c,0x95,0x0b,0x42,0xfa,0xc3,0x4e,
0x08,0x2e,0xa1,0x66,0x28,0xd9,0x24,0xb2,0x76,0x5b,0xa2,0x49,0x6d,0x8b,0xd1,0x25,
0x72,0xf8,0xf6,0x64,0x86,0x68,0x98,0x16,0xd4,0xa4,0x5c,0xcc,0x5d,0x65,0xb6,0x92,
0x6c,0x70,0x48,0x50,0xfd,0xed,0xb9,0xda,0x5e,0x15,0x46,0x57,0xa7,0x8d,0x9d,0x84,
0x90,0xd8,0xab,0x00,0x8c,0xbc,0xd3,0x0a,0xf7,0xe4,0x58,0x05,0xb8,0xb3,0x45,0x06,
0xd0,0x2c,0x1e,0x8f,0xca,0x3f,0x0f,0x02,0xc1,0xaf,0xbd,0x03,0x01,0x13,0x8a,0x6b,
0x3a,0x91,0x11,0x41,0x4f,0x67,0xdc,0xea,0x97,0xf2,0xcf,0xce,0xf0,0xb4,0xe6,0x73,
0x96,0xac,0x74,0x22,0xe7,0xad,0x35,0x85,0xe2,0xf9,0x37,0xe8,0x1c,0x75,0xdf,0x6e,
0x47,0xf1,0x1a,0x71,0x1d,0x29,0xc5,0x89,0x6f,0xb7,0x62,0x0e,0xaa,0x18,0xbe,0x1b,
0xfc,0x56,0x3e,0x4b,0xc6,0xd2,0x79,0x20,0x9a,0xdb,0xc0,0xfe,0x78,0xcd,0x5a,0xf4,
0x1f,0xdd,0xa8,0x33,0x88,0x07,0xc7,0x31,0xb1,0x12,0x10,0x59,0x27,0x80,0xec,0x5f,
0x60,0x51,0x7f,0xa9,0x19,0xb5,0x4a,0x0d,0x2d,0xe5,0x7a,0x9f,0x93,0xc9,0x9c,0xef,
0xa0,0xe0,0x3b,0x4d,0xae,0x2a,0xf5,0xb0,0xc8,0xeb,0xbb,0x3c,0x83,0x53,0x99,0x61,
0x17,0x2b,0x04,0x7e,0xba,0x77,0xd6,0x26,0xe1,0x69,0x14,0x63,0x55,0x21,0x0c,0x7d};
constexpr uint8_t rcon[11] = {0,1,2,4,8,16,32,64,128,27,54};

using RoundKeys = std::array<uint8_t, 176>;
RoundKeys expand(const Key &key) {
  RoundKeys out{};
  std::copy(key.begin(), key.end(), out.begin());
  size_t generated = 16;
  uint8_t round = 1;
  uint8_t temp[4]{};
  while (generated < out.size()) {
    std::copy_n(out.begin() + generated - 4, 4, temp);
    if (generated % 16 == 0) {
      uint8_t first = temp[0];
      temp[0] = sbox[temp[1]] ^ rcon[round++];
      temp[1] = sbox[temp[2]]; temp[2] = sbox[temp[3]]; temp[3] = sbox[first];
    }
    for (uint8_t value : temp) {
      out[generated] = out[generated - 16] ^ value;
      ++generated;
    }
  }
  return out;
}

uint8_t mul(uint8_t a, uint8_t b) {
  uint8_t result = 0;
  while (b) {
    if (b & 1) result ^= a;
    a = static_cast<uint8_t>((a << 1) ^ ((a & 0x80) ? 0x1b : 0));
    b >>= 1;
  }
  return result;
}
void add_key(uint8_t *state, const RoundKeys &keys, size_t round) {
  for (size_t i = 0; i < 16; ++i) state[i] ^= keys[round * 16 + i];
}
void shift(uint8_t *s) {
  uint8_t t[16]; std::copy_n(s, 16, t);
  for (int r=0;r<4;++r) for (int c=0;c<4;++c) s[r+4*c]=t[r+4*((c+r)%4)];
}
void inv_shift(uint8_t *s) {
  uint8_t t[16]; std::copy_n(s, 16, t);
  for (int r=0;r<4;++r) for (int c=0;c<4;++c) s[r+4*c]=t[r+4*((c-r+4)%4)];
}
void mix(uint8_t *s) {
  for (int c=0;c<4;++c) { uint8_t *a=s+4*c; uint8_t t[4]; std::copy_n(a,4,t);
    a[0]=mul(t[0],2)^mul(t[1],3)^t[2]^t[3]; a[1]=t[0]^mul(t[1],2)^mul(t[2],3)^t[3];
    a[2]=t[0]^t[1]^mul(t[2],2)^mul(t[3],3); a[3]=mul(t[0],3)^t[1]^t[2]^mul(t[3],2); }
}
void inv_mix(uint8_t *s) {
  for (int c=0;c<4;++c) { uint8_t *a=s+4*c; uint8_t t[4]; std::copy_n(a,4,t);
    a[0]=mul(t[0],14)^mul(t[1],11)^mul(t[2],13)^mul(t[3],9);
    a[1]=mul(t[0],9)^mul(t[1],14)^mul(t[2],11)^mul(t[3],13);
    a[2]=mul(t[0],13)^mul(t[1],9)^mul(t[2],14)^mul(t[3],11);
    a[3]=mul(t[0],11)^mul(t[1],13)^mul(t[2],9)^mul(t[3],14); }
}
void encrypt_block(const RoundKeys &keys, uint8_t *s) {
  add_key(s,keys,0);
  for(size_t r=1;r<10;++r){for(size_t i=0;i<16;++i)s[i]=sbox[s[i]];shift(s);mix(s);add_key(s,keys,r);}
  for(size_t i=0;i<16;++i)s[i]=sbox[s[i]]; shift(s); add_key(s,keys,10);
}
void decrypt_block(const RoundKeys &keys, uint8_t *s) {
  add_key(s,keys,10);
  for(size_t r=9;r>0;--r){inv_shift(s);for(size_t i=0;i<16;++i)s[i]=rsbox[s[i]];add_key(s,keys,r);inv_mix(s);}
  inv_shift(s); for(size_t i=0;i<16;++i)s[i]=rsbox[s[i]]; add_key(s,keys,0);
}
Bytes dbl(const Bytes &in) {
  Bytes out(16); uint8_t carry=0;
  for(int i=15;i>=0;--i){uint8_t next=in[i]>>7;out[i]=static_cast<uint8_t>((in[i]<<1)|carry);carry=next;}
  if(carry)out[15]^=0x87; return out;
}
}  // namespace

bool aes_cbc_encrypt(const Key &key, const Bytes &iv, const Bytes &plain,
                     Bytes &output) {
  if(iv.size()!=16 || plain.size()%16) { output.clear(); return false; }
  RoundKeys keys=expand(key); output.resize(plain.size()); Bytes chain=iv;
  for(size_t o=0;o<plain.size();o+=16){for(size_t i=0;i<16;++i)output[o+i]=plain[o+i]^chain[i];encrypt_block(keys,output.data()+o);std::copy_n(output.begin()+o,16,chain.begin());}
  return true;
}
bool aes_cbc_decrypt(const Key &key, const Bytes &iv, const Bytes &cipher,
                     Bytes &output) {
  if(iv.size()!=16 || cipher.size()%16) { output.clear(); return false; }
  RoundKeys keys=expand(key); output=cipher;
  for(size_t o=0;o<cipher.size();o+=16){decrypt_block(keys,output.data()+o);for(size_t i=0;i<16;++i)output[o+i]^=(o?cipher[o-16+i]:iv[i]);}
  return true;
}
Key cmac(const Key &key, const Bytes &message) {
  Bytes zero(16), l; aes_cbc_encrypt(key,zero,zero,l); Bytes k1=dbl(l), k2=dbl(k1);
  size_t blocks=message.empty()?1:(message.size()+15)/16; bool complete=!message.empty()&&message.size()%16==0;
  Bytes padded(blocks*16); std::copy(message.begin(),message.end(),padded.begin());
  if(!complete)padded[message.size()]=0x80;
  const Bytes &sub=complete?k1:k2; for(size_t i=0;i<16;++i)padded[(blocks-1)*16+i]^=sub[i];
  Bytes result; aes_cbc_encrypt(key,zero,padded,result); Key output{};std::copy_n(result.end()-16,16,output.begin());return output;
}
std::array<uint8_t,8> short_cmac(const Key &key,const Bytes &message){Key full=cmac(key,message);std::array<uint8_t,8> out{};for(size_t i=0;i<8;++i)out[i]=full[i*2+1];return out;}

bool derive_session_keys(const Key &key,const Bytes &a,const Bytes &b,
                         Key &session_enc, Key &session_mac){
  if(a.size()!=16||b.size()!=16) { session_enc={}; session_mac={}; return false; }
  Bytes common{0,0,0,1,0,0x80,a[0],a[1]};
  for(size_t i=0;i<6;++i)common.push_back(a[i+2]^b[i]);
  common.insert(common.end(),b.begin()+6,b.end()); common.insert(common.end(),a.begin()+8,a.end());
  Bytes sv1=common,sv2=common;sv1[0]=0xa5;sv1[1]=0x5a;sv2[0]=0x5a;sv2[1]=0xa5;
  session_enc=cmac(key,sv1); session_mac=cmac(key,sv2); return true;
}
uint32_t jamcrc(const Bytes &bytes){uint32_t crc=0xffffffff;for(uint8_t b:bytes){crc^=b;for(int i=0;i<8;++i)crc=(crc>>1)^((crc&1)?0xedb88320:0);}return crc;}

}  // namespace nfc_emulator::crypto
