// Host tests for the ATT-1207 reader identity code: proof tuple, RSA/DS helpers, DS record, eFuse report,
// identity upgrade message, NVS erase gate and the migration staging header. The proof vector is the same
// file the API's jest spec (identity-proof.spec.ts) checks.
#include <ArduinoJson.h>

#include <cstdio>
#include <fstream>
#include <sstream>
#include <string>
#include <vector>

#include "api/security/ds_params.hpp"
#include "api/security/ds_record.hpp"
#include "api/security/efuse_report.hpp"
#include "api/security/identity_proof.hpp"
#include "api/security/identity_upgrade.hpp"
#include "api/security/migration_pending.hpp"
#include "api/security/nvs_erase_gate.hpp"
#include "api/security/pairing_codec.hpp"
#include "api/security/rsa_der.hpp"
#include "psa/crypto.h"

using Bytes = std::vector<uint8_t>;

namespace
{
int failures = 0;

#define CHECK(condition)                                                                       \
    do                                                                                         \
    {                                                                                          \
        if (!(condition))                                                                      \
        {                                                                                      \
            std::fprintf(stderr, "%s:%d: CHECK failed: %s\n", __FILE__, __LINE__, #condition); \
            failures++;                                                                        \
        }                                                                                      \
    } while (0)

Bytes fromHex(const std::string &hex)
{
    Bytes out;
    for (size_t i = 0; i + 1 < hex.size(); i += 2)
    {
        out.push_back(static_cast<uint8_t>(std::stoi(hex.substr(i, 2), nullptr, 16)));
    }
    return out;
}

JsonDocument loadJson(const char *path)
{
    std::ifstream file(path);
    std::stringstream text;
    text << file.rdbuf();
    JsonDocument doc;
    CHECK(deserializeJson(doc, text.str()) == DeserializationError::Ok);
    return doc;
}

// A throwaway RSA-3072 key generated by PSA (what the reader's creation does on the device).
struct TestKey
{
    mbedtls_svc_key_id_t id = MBEDTLS_SVC_KEY_ID_INIT;
    RsaDer::PrivateKeyParts parts;
    Bytes spki;
};

TestKey makeKey()
{
    TestKey key;
    CHECK(psa_crypto_init() == PSA_SUCCESS);
    psa_key_attributes_t attributes = PSA_KEY_ATTRIBUTES_INIT;
    psa_set_key_type(&attributes, PSA_KEY_TYPE_RSA_KEY_PAIR);
    psa_set_key_bits(&attributes, 3072);
    psa_set_key_usage_flags(&attributes, PSA_KEY_USAGE_EXPORT | PSA_KEY_USAGE_SIGN_HASH);
    psa_set_key_algorithm(&attributes, PSA_ALG_RSA_PSS(PSA_ALG_SHA_256));
    psa_set_key_enrollment_algorithm(&attributes, PSA_ALG_RSA_PKCS1V15_SIGN(PSA_ALG_SHA_256));
    CHECK(psa_generate_key(&attributes, &key.id) == PSA_SUCCESS);
    Bytes der(PSA_EXPORT_KEY_PAIR_OR_PUBLIC_MAX_SIZE);
    size_t length = 0;
    CHECK(psa_export_key(key.id, der.data(), der.size(), &length) == PSA_SUCCESS);
    CHECK(RsaDer::parsePrivateKey(der.data(), length, key.parts));
    key.spki = RsaDer::spkiFromModulus(key.parts.modulus.data(), key.parts.modulus.size());
    return key;
}

bool verifyPss(const Bytes &spki, const Bytes &message, const Bytes &signature)
{
    constexpr size_t HEADER = RsaDer::SPKI_BYTES - 398;
    const Bytes publicDer(spki.begin() + HEADER, spki.end());
    psa_key_attributes_t attributes = PSA_KEY_ATTRIBUTES_INIT;
    psa_set_key_type(&attributes, PSA_KEY_TYPE_RSA_PUBLIC_KEY);
    psa_set_key_bits(&attributes, 3072);
    psa_set_key_usage_flags(&attributes, PSA_KEY_USAGE_VERIFY_HASH);
    // PSA_ALG_RSA_PSS requires the salt length to equal the hash length (32): exactly what the server checks.
    psa_set_key_algorithm(&attributes, PSA_ALG_RSA_PSS(PSA_ALG_SHA_256));
    mbedtls_svc_key_id_t verifier = MBEDTLS_SVC_KEY_ID_INIT;
    if (psa_import_key(&attributes, publicDer.data(), publicDer.size(), &verifier) != PSA_SUCCESS)
    {
        return false;
    }
    uint8_t digest[32];
    size_t digestLength = 0;
    psa_hash_compute(PSA_ALG_SHA_256, message.data(), message.size(), digest, sizeof(digest), &digestLength);
    const bool ok = psa_verify_hash(verifier, PSA_ALG_RSA_PSS(PSA_ALG_SHA_256), digest, digestLength, signature.data(),
                                    signature.size()) == PSA_SUCCESS;
    psa_destroy_key(verifier);
    return ok;
}

bool signPss(const TestKey &key, const Bytes &message, Bytes &signature)
{
    uint8_t digest[32];
    size_t digestLength = 0;
    psa_hash_compute(PSA_ALG_SHA_256, message.data(), message.size(), digest, sizeof(digest), &digestLength);
    signature.assign(RsaDer::MODULUS_BYTES, 0);
    size_t length = 0;
    return psa_sign_hash(key.id, PSA_ALG_RSA_PSS(PSA_ALG_SHA_256), digest, digestLength, signature.data(),
                         signature.size(), &length) == PSA_SUCCESS &&
           length == signature.size();
}

// --- proof tuple ------------------------------------------------------------------------------

void testProofVector()
{
    JsonDocument v = loadJson(PROOF_VECTOR);
    const Bytes tuple = IdentityProof::tuple(v["installationId"].as<std::string>(), v["readerId"].as<uint32_t>(),
                                             fromHex(v["oldFingerprintHex"].as<std::string>()),
                                             fromHex(v["newSpkiHex"].as<std::string>()),
                                             fromHex(v["nonceHex"].as<std::string>()));
    CHECK(tuple == fromHex(v["tupleHex"].as<std::string>()));
    CHECK(std::string(IdentityProof::DOMAIN) == v["domain"].as<std::string>());
    // Another reader, installation or nonce changes the bytes (domain separation).
    CHECK(IdentityProof::tuple("installation-test-2", 42, fromHex(v["oldFingerprintHex"].as<std::string>()),
                               fromHex(v["newSpkiHex"].as<std::string>()),
                               fromHex(v["nonceHex"].as<std::string>())) != tuple);
    CHECK(IdentityProof::tuple(v["installationId"].as<std::string>(), 43,
                               fromHex(v["oldFingerprintHex"].as<std::string>()),
                               fromHex(v["newSpkiHex"].as<std::string>()),
                               fromHex(v["nonceHex"].as<std::string>())) != tuple);
}

// --- RSA / DS helpers -------------------------------------------------------------------------

void testRsaDer(const TestKey &key)
{
    CHECK(key.spki.size() == RsaDer::SPKI_BYTES);
    CHECK(RsaDer::isCanonicalRsa3072Spki(key.spki));
    CHECK(RsaDer::modulusFromSpki(key.spki) == key.parts.modulus);
    Bytes bad = key.spki;
    bad[bad.size() - 1] ^= 0x02; // e = 65539
    CHECK(!RsaDer::isCanonicalRsa3072Spki(bad));
    bad = key.spki;
    bad.pop_back();
    CHECK(!RsaDer::isCanonicalRsa3072Spki(bad));
    bad = key.spki;
    bad[30] ^= 0x01; // not the rsaEncryption / 3072 framing any more
    CHECK(!RsaDer::isCanonicalRsa3072Spki(bad));
    CHECK(!RsaDer::isCanonicalRsa3072Spki(Bytes(91, 0x30)));
    Bytes even = key.parts.modulus;
    even.back() &= 0xfe;
    CHECK(RsaDer::spkiFromModulus(even.data(), even.size()).empty());
    CHECK(RsaDer::spkiFromModulus(key.parts.modulus.data(), 383).empty());
}

void testDsParams()
{
    JsonDocument v = loadJson(DS_PARAMS_VECTOR);
    const Bytes n = fromHex(v["modulusHex"].as<std::string>());
    const Bytes d = fromHex(v["privateExponentHex"].as<std::string>());
    const Bytes rb = fromHex(v["rbHex"].as<std::string>());
    DsParams::Operands out;
    CHECK(DsParams::compute(n.data(), d.data(), out));
    auto words = [](const Bytes &big) {
        std::vector<uint32_t> w(DsParams::MAX_WORDS, 0);
        for (size_t i = 0; i < big.size() / 4; i++)
        {
            const uint8_t *p = big.data() + big.size() - 4 * (i + 1);
            w[i] = (uint32_t(p[0]) << 24) | (uint32_t(p[1]) << 16) | (uint32_t(p[2]) << 8) | p[3];
        }
        return w;
    };
    const std::vector<uint32_t> m = words(n), y = words(d), r = words(rb);
    CHECK(std::equal(m.begin(), m.end(), out.M));
    CHECK(std::equal(y.begin(), y.end(), out.Y));
    CHECK(std::equal(r.begin(), r.end(), out.Rb));
    CHECK(out.M_prime == v["mPrime"].as<uint32_t>());
    CHECK(out.length == 95);
    // Unused words stay zero (the peripheral takes 4096-bit operands).
    for (size_t i = DsParams::KEY_WORDS; i < DsParams::MAX_WORDS; i++)
    {
        CHECK(out.M[i] == 0 && out.Y[i] == 0 && out.Rb[i] == 0);
    }
    Bytes even = n;
    even.back() &= 0xfe;
    CHECK(!DsParams::compute(even.data(), d.data(), out));
}

// --- DS record --------------------------------------------------------------------------------

DsRecord::Record makeRecord(const Bytes &spki)
{
    DsRecord::Record record;
    for (size_t i = 0; i < DsRecord::IV_BYTES; i++)
    {
        record.iv[i] = static_cast<uint8_t>(0x40 + i);
    }
    record.c.resize(DsRecord::C_BYTES);
    for (size_t i = 0; i < record.c.size(); i++)
    {
        record.c[i] = static_cast<uint8_t>(i * 7);
    }
    record.spki = spki;
    return record;
}

void testDsRecord(const TestKey &key)
{
    const DsRecord::Record record = makeRecord(key.spki);
    const Bytes raw = DsRecord::serialize(record);
    CHECK(!raw.empty() && raw.size() < DsRecord::SECTOR_BYTES);
    CHECK(raw.size() == DsRecord::HEADER_BYTES + 1 + 1 + 2 + 16 + 2 + DsRecord::C_BYTES + 2 + RsaDer::SPKI_BYTES);
    CHECK(raw[0] == 'A' && raw[1] == 'T' && raw[2] == 'D' && raw[3] == 'S');

    DsRecord::Record parsed;
    CHECK(DsRecord::parse(raw.data(), raw.size(), parsed));
    CHECK(parsed.c == record.c && parsed.spki == record.spki && parsed.keyBlock == 3 && parsed.rsaLength == 95);
    CHECK(memcmp(parsed.iv, record.iv, sizeof(parsed.iv)) == 0);

    // A whole flash sector: the record, then erased 0xFF bytes.
    Bytes sector = raw;
    sector.resize(DsRecord::SECTOR_BYTES, 0xFF);
    CHECK(DsRecord::parse(sector.data(), sector.size(), parsed));
    // Erased and garbage sectors are no record.
    CHECK(!DsRecord::parse(Bytes(DsRecord::SECTOR_BYTES, 0xFF).data(), DsRecord::SECTOR_BYTES, parsed));
    CHECK(!DsRecord::parse(Bytes(DsRecord::SECTOR_BYTES, 0x00).data(), DsRecord::SECTOR_BYTES, parsed));

    // Any flipped byte of the payload breaks the hash; header fields are validated too.
    for (size_t position : {size_t(0), size_t(4), size_t(6), size_t(8), size_t(12), size_t(44), size_t(60),
                            raw.size() / 2, raw.size() - 1})
    {
        Bytes bad = raw;
        bad[position] ^= 0x01;
        CHECK(!DsRecord::parse(bad.data(), bad.size(), parsed));
    }
    CHECK(!DsRecord::parse(raw.data(), raw.size() - 1, parsed)); // truncated
    // Wrong lengths are refused when serializing.
    DsRecord::Record bad = record;
    bad.c.pop_back();
    CHECK(DsRecord::serialize(bad).empty());
    bad = record;
    bad.spki[bad.spki.size() - 1] ^= 0x02;
    CHECK(DsRecord::serialize(bad).empty());
    bad = record;
    bad.keyBlock = 6;
    CHECK(DsRecord::serialize(bad).empty());
}

// --- identity upgrade message -----------------------------------------------------------------

void testUpgradeMessage(const TestKey &key)
{
    JsonDocument v = loadJson(PROOF_VECTOR);
    IdentityUpgrade::Context context;
    context.installationId = "installation-test-1";
    context.readerId = 42;
    context.oldSpki = Bytes(91, 0x42); // stands in for the P-256 SPKI
    context.newSpki = key.spki;
    context.sign = [&key](const Bytes &message, Bytes &signature) { return signPss(key, message, signature); };

    const Bytes nonce(32, 0x5a);
    std::string message;
    CHECK(IdentityUpgrade::upgradeMessage(context, PairingCodec::base64Encode(nonce), message));
    JsonDocument doc;
    CHECK(deserializeJson(doc, message) == DeserializationError::Ok);
    CHECK(doc["t"] == "identity.upgrade");
    Bytes spki, proof;
    CHECK(PairingCodec::base64Decode(doc["spki"].as<std::string>(), spki) && spki == key.spki);
    CHECK(PairingCodec::base64Decode(doc["proof"].as<std::string>(), proof));
    CHECK(proof.size() == RsaDer::MODULUS_BYTES);

    // The proof verifies over exactly the documented tuple, with RSA-PSS and a 32-byte salt.
    Bytes fingerprint;
    CHECK(IdentityUpgrade::fingerprint(context.oldSpki, fingerprint));
    const Bytes tuple = IdentityProof::tuple("installation-test-1", 42, fingerprint, key.spki, nonce);
    CHECK(verifyPss(key.spki, tuple, proof));
    // ...and over nothing else: another reader, nonce or old key does not verify.
    CHECK(!verifyPss(key.spki, IdentityProof::tuple("installation-test-1", 43, fingerprint, key.spki, nonce), proof));
    CHECK(!verifyPss(key.spki, IdentityProof::tuple("installation-test-1", 42, fingerprint, key.spki, Bytes(32, 0x5b)),
                     proof));
    Bytes otherFingerprint = fingerprint;
    otherFingerprint[0] ^= 1;
    CHECK(!verifyPss(key.spki, IdentityProof::tuple("installation-test-1", 42, otherFingerprint, key.spki, nonce), proof));

    // Rejected inputs: nonce of the wrong size, not base64, a non-RSA-3072 SPKI, no signer.
    CHECK(!IdentityUpgrade::upgradeMessage(context, PairingCodec::base64Encode(Bytes(31, 1)), message));
    CHECK(!IdentityUpgrade::upgradeMessage(context, "not base64!", message));
    IdentityUpgrade::Context broken = context;
    broken.newSpki = Bytes(91, 0x30);
    CHECK(!IdentityUpgrade::upgradeMessage(broken, PairingCodec::base64Encode(nonce), message));
    broken = context;
    broken.sign = nullptr;
    CHECK(!IdentityUpgrade::upgradeMessage(broken, PairingCodec::base64Encode(nonce), message));
    broken = context;
    broken.sign = [](const Bytes &, Bytes &) { return false; };
    CHECK(!IdentityUpgrade::upgradeMessage(broken, PairingCodec::base64Encode(nonce), message));
    CHECK(IdentityUpgrade::requestMessage() == "{\"t\":\"identity.upgrade.request\"}");
}

// --- eFuse report -----------------------------------------------------------------------------

void testEfuseReport()
{
    EfuseReport::Snapshot s;
    s.mac = "dc:b4:d9:21:71:c8";
    s.secureBootEn = true;
    const char *purposes[] = {"SECURE_BOOT_DIGEST0", "SECURE_BOOT_DIGEST1", "XTS_AES_128_KEY",
                              "HMAC_DOWN_DIGITAL_SIGNATURE", "HMAC_UP", "USER"};
    for (size_t i = 0; i < EfuseReport::KEY_BLOCKS; i++)
    {
        s.keys[i].purpose = purposes[i];
        s.keys[i].used = i < 5;
        s.keys[i].readProtected = i >= 2 && i < 5;
    }
    s.digest0 = std::string(64, 'a');
    s.digest1 = std::string(64, 'b');
    s.revoke[2] = true;
    s.cryptCnt = 7;
    s.cryptCntWriteProtected = true;
    s.disDownloadManualEncrypt = true;
    s.jtagPadDisabled = s.jtagUsbDisabled = true;
    s.enableSecurityDownload = true;
    s.rdDis = 0x1c;
    s.rdDisWriteProtected = true;
    s.secureVersion = 1;
    s.flashEncryptionMode = "release";
    std::string json;
    CHECK(EfuseReport::toJson(s, json));
    CHECK(json.size() < EfuseReport::MAX_BYTES);
    JsonDocument doc;
    CHECK(deserializeJson(doc, json) == DeserializationError::Ok);
    CHECK(doc["t"] == "efuse.report" && doc["mac"] == "dc:b4:d9:21:71:c8" && doc["secureBootEn"] == true);
    CHECK(doc["keys"].size() == 6 && doc["keys"][3]["purpose"] == "HMAC_DOWN_DIGITAL_SIGNATURE" &&
          doc["keys"][3]["readProtected"] == true && doc["keys"][0]["readProtected"] == false);
    CHECK(doc["digest0"] == std::string(64, 'a') && doc["digest1"] == std::string(64, 'b'));
    CHECK(doc["revoke"].size() == 3 && doc["revoke"][2] == true && doc["revoke"][0] == false);
    CHECK(doc["cryptCnt"] == 7 && doc["cryptCntWriteProtected"] == true && doc["disDownloadManualEncrypt"] == true);
    CHECK(doc["jtag"]["padDisabled"] == true && doc["jtag"]["usbDisabled"] == true && doc["jtag"]["softDisJtag"] == 0);
    CHECK(doc["download"]["enableSecurityDownload"] == true && doc["download"]["disDownloadMode"] == false &&
          doc["download"]["disForceDownload"] == false && doc["download"]["disUsbSerialJtagDownload"] == false);
    CHECK(doc["rdDis"] == 0x1c && doc["rdDisWriteProtected"] == true && doc["secureVersion"] == 1 &&
          doc["flashEncryptionMode"] == "release");
    // KEY0/KEY1 that hold no Secure Boot digest report null; nothing but the two digests carries key data.
    s.digest0.clear();
    CHECK(EfuseReport::toJson(s, json));
    CHECK(deserializeJson(doc, json) == DeserializationError::Ok && doc["digest0"].isNull());
    CHECK(EfuseReport::hex(reinterpret_cast<const uint8_t *>("\x01\xab"), 2) == "01ab");
}

// --- NVS erase gate and migration staging -----------------------------------------------------

void testEraseGate()
{
    using R = NvsEraseGate::NvsInitResult;
    // Plain builds: unchanged behaviour. Erase on the two recoverable errors only; a pending
    // migration is not even consulted (main.cpp passes false).
    CHECK(NvsEraseGate::shouldErase(R::NoFreePages, false, false));
    CHECK(NvsEraseGate::shouldErase(R::NewVersionFound, false, false));
    CHECK(!NvsEraseGate::shouldErase(R::Ok, false, false));
    CHECK(!NvsEraseGate::shouldErase(R::OtherError, false, false));
    // Secure builds: same two errors, but never while a migration is pending.
    CHECK(NvsEraseGate::shouldErase(R::NoFreePages, true, false));
    CHECK(NvsEraseGate::shouldErase(R::NewVersionFound, true, false));
    CHECK(!NvsEraseGate::shouldErase(R::NoFreePages, true, true));
    CHECK(!NvsEraseGate::shouldErase(R::NewVersionFound, true, true));
    // Encryption / HMAC key errors never erase on a secure build, pending or not.
    CHECK(!NvsEraseGate::shouldErase(R::OtherError, true, false));
    CHECK(!NvsEraseGate::shouldErase(R::OtherError, true, true));
    CHECK(!NvsEraseGate::shouldErase(R::Ok, true, true));
}

void testMigrationStaging()
{
    uint8_t sector[16] = {'A', 'T', 'M', 'G'};
    CHECK(MigrationStaging::headerPresent(sector, sizeof(sector)));
    uint8_t erased[16];
    memset(erased, 0xFF, sizeof(erased));
    CHECK(!MigrationStaging::headerPresent(erased, sizeof(erased)));
    CHECK(!MigrationStaging::headerPresent(sector, 3));
    CHECK(!MigrationStaging::headerPresent(nullptr, 16));
    // No staging exists in ATT-1207: the device check reads false on the host.
    CHECK(!migrationPending());
    // The staging header sits in the last sector of spiffs, the DS record in the first.
    CHECK(MigrationStaging::HEADER_OFFSET == 0xc90000 + 0x350000 - 0x1000);
    CHECK(DsRecord::FLASH_OFFSET == MigrationStaging::SPIFFS_OFFSET);
}
}

int main()
{
    testProofVector();
    testEraseGate();
    testMigrationStaging();
    testEfuseReport();
    testDsParams();
    const TestKey key = makeKey();
    testRsaDer(key);
    testDsRecord(key);
    testUpgradeMessage(key);
    if (failures)
    {
        std::fprintf(stderr, "%d check(s) failed\n", failures);
        return 1;
    }
    std::puts("identity-upgrade host tests passed");
    return 0;
}
